inherit pypi setuptools3
require python-flask-jsonpify.inc