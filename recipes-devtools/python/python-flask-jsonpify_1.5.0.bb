inherit pypi setuptools
require python-flask-jsonpify.inc