require python-scipy.inc