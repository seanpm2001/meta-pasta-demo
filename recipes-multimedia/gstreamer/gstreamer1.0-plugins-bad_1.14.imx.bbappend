PACKAGECONFIG_remove_mx6 = " vulkan "
