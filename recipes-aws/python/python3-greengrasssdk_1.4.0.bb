inherit pypi setuptools3
require python-greengrasssdk.inc