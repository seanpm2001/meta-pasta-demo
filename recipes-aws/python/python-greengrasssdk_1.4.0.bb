inherit pypi setuptools
require python-greengrasssdk.inc