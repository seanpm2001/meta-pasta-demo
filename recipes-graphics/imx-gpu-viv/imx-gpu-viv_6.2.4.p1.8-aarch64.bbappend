EXTRA_PROVIDES_append_mx8 = " vulkan "

COMPATIBLE_MACHINE = "(mx8|apalis-imx8)"